# Keil uVision project I2c.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(33000000) MODAT2
  output: I2c
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: i2c.c delay2.c lcd1.c keypad1.c rtcassign1.c
